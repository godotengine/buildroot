## package/scons/Config.in.host
```kconfig
config BR2_PACKAGE_HOST_SCONS
       bool "host scons"
       help
         SCons 4.8.1
```
